# Enable on wlan0 only
FILESEXTRAPATHS_append := ":${THISDIR}/files"
SRC_URI += "file://0001-enable-on-wlan0-only.patch"
