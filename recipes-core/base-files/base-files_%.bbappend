# Set hostname
hostname="qtipi"
